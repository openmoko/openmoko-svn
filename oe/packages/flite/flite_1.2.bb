require flite.inc
SRC_URI += "file://flite-1.2-alsa_support-1.2.diff;patch=1;pnum=0"

PR = "r4"

