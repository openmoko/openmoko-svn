require openmoko-image.bb

export PACKAGE_INSTALL += "\
  task-openmoko-demo \
  task-openmoko-examples \
  task-openmoko-debug \
"
