require linux-gta01_2.6.20.5.bb
