require linux-gta01.inc

MOKOR = "moko8"
PR = "${MOKOR}-r1"

VANILLA_VERSION = "2.6.20.4"

