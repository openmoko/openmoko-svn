require linux-qt2410_2.6.17.14.bb
