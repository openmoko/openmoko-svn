DESCRIPTION = "The OpenMoko Application Manager"
SECTION = "openmoko/applications"
PV = "0.0.1+svn${SRCDATE}"

inherit openmoko

