DESCRIPTION = "The OpenMoko Feed Reader"
SECTION = "openmoko/applications"
DEPENDS += "libmrss"
PV = "0.0.1+svn${SRCDATE}"

inherit openmoko

