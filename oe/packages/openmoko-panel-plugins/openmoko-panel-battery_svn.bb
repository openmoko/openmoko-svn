DESCRIPTION = "Shows the battery/AC status in the OpenMoko panel"
DEPENDS += "apmd"
PV = "0.0.1+svn${SRCDATE}"
PR = "r1"

inherit openmoko-panel-plugin

