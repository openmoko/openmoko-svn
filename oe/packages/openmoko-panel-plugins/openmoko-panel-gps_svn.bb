DESCRIPTION = "Shows the GPS status in the OpenMoko panel"
PV = "0.0.1+svn${SRCDATE}"

inherit openmoko-panel-plugin

