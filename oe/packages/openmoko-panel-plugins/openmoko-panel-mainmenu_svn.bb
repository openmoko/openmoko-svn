DESCRIPTION = "A finger based main menu for the OpenMoko panel"
PV = "0.1.0+svn${SRCDATE}"

DEPENDS += "libmatchbox libpulse startup-notification"

inherit openmoko-panel-plugin

