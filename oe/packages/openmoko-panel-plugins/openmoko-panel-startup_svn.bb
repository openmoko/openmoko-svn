DESCRIPTON = "Shows the application startup in the OpenMoko panel"
DEPENDS += "startup-notification"
PV = "0.0.1+svn${SRCDATE}"
PR = "r1"

inherit openmoko-panel-plugin
