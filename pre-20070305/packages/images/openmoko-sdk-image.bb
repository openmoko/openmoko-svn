require openmoko-devel-image.bb

export IPKG_INSTALL += "\
  task-openmoko-native-sdk \
"
