require linux-gta01_2.6.20.1.bb
